# Keil uVision project IIC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: IIC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: delay.c iic.c main.c lcd1602.c pcf8591.c timer.c
