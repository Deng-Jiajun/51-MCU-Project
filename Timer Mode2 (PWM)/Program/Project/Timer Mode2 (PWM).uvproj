# Keil uVision project Timer Mode2 (PWM).uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Timer Mode2 (PWM) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../Source/: delay.c ExternalInterrupt.c led.c main.c timer.c
